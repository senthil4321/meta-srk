# Enable libkcapi apps and hasher for hardware crypto testing
# This enables kcapi-hasher, kcapi-speed, and other tools
PACKAGECONFIG:append = " apps"
