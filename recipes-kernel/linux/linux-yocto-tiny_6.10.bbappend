FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://net.cfg"